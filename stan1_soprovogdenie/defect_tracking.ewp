# IAR project defect_tracking.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x60
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  XLINK.XExtraOptions: -we133=i; -Ointel-extended,(CODE)=Debug\Exe\prog.hex; -Ointel-extended,(XDATA)=Debug\Exe\eeprom.hex
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: crc.c defect.c eeprom.c eeprom_user.c indicator.c koleso.c lcd_16.c main.c OutDataPc.c pulsar.c rez.c rs232.c rs485.c timer.c upor.c
